#SUMMARY = "QTI Audio Package Group"

LICENSE = "BSD-3-Clause"

RDEPENDS_packagegroup-qti-audio += ' \
    pal \
    mcs \
'
